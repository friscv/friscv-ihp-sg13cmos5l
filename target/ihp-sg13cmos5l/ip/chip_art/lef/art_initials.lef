VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO art_initials
  CLASS BLOCK ;
  FOREIGN art_initials ;
  ORIGIN 0.000 0.000 ;
  SIZE 241.000 BY 76.000 ;
  OBS
      LAYER Metal1 ;
        RECT 0.000 0.000 241.000 76.000 ;
      LAYER Metal2 ;
        RECT 0.000 0.000 241.000 76.000 ;
      LAYER Metal3 ;
        RECT 0.000 0.000 241.000 76.000 ;
      LAYER Metal4 ;
        RECT 0.000 0.000 241.000 76.000 ;
      LAYER TopMetal1 ;
        RECT 0.000 0.000 241.000 76.000 ;
  END
END art_initials
END LIBRARY
